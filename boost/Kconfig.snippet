## boost/Kconfig.snippet
```kconfig
config INPUT_BOOST_M30S
	bool "Touch input boost for the M30s (CPU min frequency on touch)"
	depends on INPUT
	default n
```
